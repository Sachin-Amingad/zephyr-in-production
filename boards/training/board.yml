## boards/training/board.yml
```yaml
board:
  name: training
  full_name: Training
  vendor: nxp
  socs:
  - name: mcxa156
```
